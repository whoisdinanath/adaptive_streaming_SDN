options:
  parameters:
    generate_options: qt_gui
    id: default
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: noise_amp
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.05'
    stop: '1'
    value: '0'
  states: {}
- name: qpsk
  id: variable_constellation
  parameters:
    const_points: '[-1-1j, -1+1j, 1+1j, 1-1j]'
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    type: calcdist
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: '32000'
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: channels_dynamic_channel_model_0
  id: channels_dynamic_channel_model
  parameters:
    LOS: 'False'
    N: '8'
    cfo_maxdev: 1e3
    cfo_stdev: '0.01'
    delays: '[0.0, 0.1, 0.3]'
    fD: '0'
    mags: '[1.0, 0.99,1.0]'
    noise_amp: noise_amp
    ntaps: '1'
    samp_rate: samp_rate
    seed: '42'
    sro_maxdev: 1e3
    sro_stdev: '0.01'
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk
    differential: 'True'
    excess_bw: '0.35'
    samples_per_symbol: '2'
  states: {}
- name: digital_glfsr_source_x_0
  id: digital_glfsr_source_x
  parameters:
    degree: '16'
    mask: '0'
    repeat: 'True'
    seed: '1'
    type: byte
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          def __init__(self, alpha=0.1):
              gr.sync_block.__init__(self, 
                  name="Linear Bitrate Calc", 
                  in_sig=[np.complex64], 
                  out_sig=[np.float32])
              
              # 1. DEFINITIONS
              self.pwr_min = 0.3       # Baseline Power (Slider = 0)
              self.pwr_max = 1.3       # Max Power (Slider = 1)
              
              self.rate_max = 10000000.0 # 10 Mbps
              self.rate_min = 1000000.0  # 1 Mbps
              
              self.alpha = alpha       # Smoothing factor
              self.avg_power = 0.0     # State variable

          def work(self, input_items, output_items):
              if len(input_items[0]) == 0: return 0
                  
              # 2. CALCULATE POWER
              inst_power = np.mean(np.abs(input_items[0])**2)
              
              # 3. SMOOTHING
              self.avg_power = (self.alpha * inst_power) + ((1 - self.alpha) * self.avg_power)
              
              # 4. MAPPING (The Fix)
              # First, find where we are in the power range (0.0 to 1.0)
              # This value increases QUADRATICALLY (slow start, fast finish)
              raw_factor = np.clip((self.avg_power - self.pwr_min) / (self.pwr_max - self.pwr_min), 0.0, 1.0)
              
              # We apply Square Root to "Linearize" it relative to the slider
              # If raw_factor is 0.25 (25% power), sqrt(0.25) = 0.5 (50% slider)
              linear_factor = np.sqrt(raw_factor)
              
              # 5. CALCULATE RATE
              # Now we use the linear_factor
              current_rate = self.rate_max - (linear_factor * (self.rate_max - self.rate_min))
              
              # 6. ROUNDING
              current_rate = round(current_rate / 100000) * 100000
              
              # DEBUG
              print(f"PWR: {self.avg_power:.2f} | FACTOR: {linear_factor:.2f} | RATE: {current_rate/1e6:.1f} Mbps", end='\r')

              output_items[0][:] = current_rate
              return len(output_items[0])
    alpha: '0.1'
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:5555
    key: BITRATE
    timeout: '100'
    type: float
  states: {}

connections:
- [blocks_keep_one_in_n_0, '0', zeromq_pub_sink_0, '0']
- [blocks_throttle2_0, '0', digital_constellation_modulator_0, '0']
- [channels_dynamic_channel_model_0, '0', epy_block_0, '0']
- [digital_constellation_modulator_0, '0', channels_dynamic_channel_model_0, '0']
- [digital_glfsr_source_x_0, '0', blocks_throttle2_0, '0']
- [epy_block_0, '0', blocks_keep_one_in_n_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
